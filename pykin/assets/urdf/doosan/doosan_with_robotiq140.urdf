Commit message: change gripper orientation!

File: pykin/assets/urdf/doosan/doosan_with_robotiq140.urdf (robot description, URDF)
Before this commit: robot doosan, 24 links, 23 joints
Joints:
- joint right_hand_fixed: origin xyz=0 0 0 rpy=0 0 -1.5707963 -> xyz=0 0 0 rpy=0 0 0
